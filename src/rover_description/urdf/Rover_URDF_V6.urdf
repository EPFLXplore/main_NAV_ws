Commit message: motor on chassis

File: src/rover_description/urdf/Rover_URDF_V6.urdf (robot description, URDF)
Before this commit: robot rover, 11 links, 10 joints
Joints:
- joint ROCKER_LEFT: limit lower=-3.14 upper=3.14 effort=0 velocity=0 -> lower=-3.14 upper=3.14 effort=100 velocity=30
